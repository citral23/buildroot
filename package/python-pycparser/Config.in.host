## package/python-pycparser/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_PYTHON_PYCPARSER
	bool "host python-pycparser"
	help
	  https://github.com/eliben/pycparser
```
